# Keil uVision project thermostat.uvproj, settings and files
target LPC1768 Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: thermostat
  c flags: Optim=1
  c include: ../
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group System
    ./: startup_LPC17xx.s GLCD.h GLCD_SPI_LPC1700.c system_LPC17xx.c
  group Main
    ./: main.c thermostat.c thermostat.h debounced_buttons.c debounced_buttons.h
  group FSM
    ../fsm/: fsm.c fsm.h
